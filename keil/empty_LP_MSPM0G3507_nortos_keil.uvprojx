# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target MSPM0G3507_Project (6240000::V6.24::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__,MPU6050,MOTION_DRIVER_TARGET_MSPM0
  c include: ..\source;..\source\third_party\CMSIS\Core\Include;..\Hardware;..\..\WHEELTEC_C07A_R3XAkm;..\Control
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c empty.c
    ./: startup_mspm0g350x_uvision.s
    ../Hardware/: board.c
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c
    ../source/ti/driverlib/m0p/: dl_interrupt.c
    ../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/: driverlib.a
  group Hardware
    ../Hardware/: oled.c key.c led.c motor.c servo.c encoder.c adc.c IR_Module.c
    ../Hardware/imu/: imu.c imu_bus.c inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Control
    ../Control/: control.c show.c DataScope_DP.C uart_callback.c vision_protocol.c ball_state_observer.c ball_balance.c ball_position_feedforward.c ball_position_capture.c ball_hold_lap.c ball_static_task.c turn_calibration.c straight_turn_test.c startup_motion_gate.c
